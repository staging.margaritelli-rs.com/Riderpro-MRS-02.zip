Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 5e54f2e1-29ca-4821-a1a2-0ef458054bc5, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: Riderpro-MRS-02.ifc
Time: 2025-10-19T13:40:45+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ITA) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey: Livello:Livello 1, Livello 1
LongName: Livello 1; Elevation: 0 mm
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello 1; ID tipo: 1899; Tipo: Livello 1
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello 1

# IfcRailing: Riderpro-MRS-02_R23:Riderpro-MRS-02_R23, Riderpro-MRS-02_R23:Riderpro-MRS-02_R23:6392
In: Livello 1
Type - Material: <Unnamed>
Type - Altro - Categoria: Ringhiere: Supporti; Nome famiglia: Riderpro-MRS-02_R23
Type - Costruzione - Altezza: 125 mm
Type - Dati identità - Acciaio CAM Strade: conforme; Applicazione: su barriera H2BL-01; certificazione: crash test; Classe km/h: 60; Connessione: H2BL-01; Costo: 128.75; Descrizione: (colore); EPD: no; GWP totale cradle to gate: n.a.; interasse: 2; Legno CAM Strade: n.a.; Livello di severità: 1; materiale: Acciaio S350GD+Z600 + verniciatura a polvere; Modello: RIDERPRO-MRS-02; Nome del tipo: Riderpro-MRS-02_R23; norma di riferimento: CEN/TS 17342; Prezzo di Capitolato: 128.75; Prodotto: Dispositivo di sicurezza per motociclisti; Produttore: Margaritelli Road SafetyMargaritelli Road SafetyMargaritelli Road Safety; Unità di Misura: m; URL: https://margaritelli-rs.com/it/products/riderpro-mrs-02/; URL (certificati CE. DOP. manuali. schede tecniche. schemi): https://margaritelli-rs.com/it/products/riderpro-mrs-02/
Type - Pset_ManufacturerTypeInformation - Manufacturer: Margaritelli Road SafetyMargaritelli Road SafetyMargaritelli Road Safety
Pset_QuantityTakeOff - Reference: Riderpro-MRS-02_R23
Pset_RailingCommon - Reference: Riderpro-MRS-02_R23; IsExternal: no
Altro - Famiglia: Riderpro-MRS-02_R23; Famiglia e tipo: Riderpro-MRS-02_R23: Riderpro-MRS-02_R23; ID tipo: 6364; Tipo: Riderpro-MRS-02_R23
Vincoli - Gioco mano: 0 mm; Host: Livello : Livello 1; Livello: Livello 1; Offset da host: 0 mm; Sposta con gli elementi più vicini: no
Quote - Area: 2.47816 m2; Volume: 0.00314783 m3
Dati identità - Bordo_Dx: yes; Bordo_Sx: yes
